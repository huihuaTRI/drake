Commit message: Add camera to the scene

File: examples/coke_cam/urdf/couch_rough.urdf (robot description, URDF)
Before this commit: robot coke_can, 1 links, 0 joints
Links:
- removed link can
- added link couch, mass 26.1; collision box size=0.1 0.1 0.1; visual box size=0.1 0.1 0.1
